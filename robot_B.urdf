Commit message: got two blocks in the same space!!

File: robot_B.urdf (robot description, URDF)
Before this commit: robot robot, 1 links, 0 joints
Links:
- removed link Torso
- added link Torso_B, mass 1; collision box size=1 1 1; visual box size=1 1 1
